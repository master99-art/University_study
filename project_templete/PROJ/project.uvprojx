# Keil uVision project project.uvprojx, settings and files
target project (5060960::V5.06 update 7 (build 960)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.4.1
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: project
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\CMSIS\CM3\CoreSupport;..\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\STM32F10x_StdPeriph_Driver\inc;..\USER;..\FreeRTOS\include;..\FreeRTOS\portable\RVDS\ARM_CM3;..\SYSTEM;..\HARDWARE\PWM\ENCOUDER;..\HARDWARE\PWM\MOTOR;..\HARDWARE\PWM\PWM;..\HARDWARE\TIMER;..\HARDWARE\PID;..\HARDWARE\Cla;..\HARDWARE\USART;..\HARDWARE\OLED;..\HARDWARE\MPU6050;..\HARDWARE\DMP;..\HARDWARE\Control;..\HARDWARE\DMP;..\HARDWARE\IIC
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_hd.s
  group USER
    ../USER/: main.c stm32f10x_it.c
  group STM32F10x_StdPeriph_Driver
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_adc.c stm32f10x_bkp.c stm32f10x_can.c stm32f10x_cec.c stm32f10x_crc.c stm32f10x_dac.c stm32f10x_dbgmcu.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_flash.c stm32f10x_fsmc.c stm32f10x_gpio.c stm32f10x_i2c.c stm32f10x_iwdg.c stm32f10x_pwr.c stm32f10x_rcc.c stm32f10x_rtc.c stm32f10x_sdio.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_usart.c stm32f10x_wwdg.c
  group CMSIS
    ../HARDWARE/PWM/ENCOUDER/: encouder.c
    ../CMSIS/CM3/CoreSupport/: core_cm3.c
    ../CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
  group SYSTEM
    ../SYSTEM/: Delay.c
  group HARDWARE
    ../HARDWARE/PWM/PWM/: pwm.c
    ../HARDWARE/PWM/MOTOR/: motor.c
    ../HARDWARE/TIMER/: timer.c
    ../HARDWARE/PID/: pid.c
    ../HARDWARE/Cla/: Cla.c
    ../HARDWARE/USART/: usart.c
    ../HARDWARE/OLED/: oled.c
    ../HARDWARE/MPU6050/: mpu6050.c
    ../HARDWARE/Control/: Control.c
